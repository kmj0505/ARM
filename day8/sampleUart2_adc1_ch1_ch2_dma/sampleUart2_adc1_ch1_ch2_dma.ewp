# IAR project sampleUart2_adc1_ch1_ch2_dma.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: C:\Program Files\IAR Systems\Libraries\CMSIS\Device\ST\STM32F4xx\Include; C:\Program Files\IAR Systems\Libraries\STM32F4xx_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sampleUart2_adc1_ch1_ch2_dma.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c uart2.c
    ../../../../../Program Files/IAR Systems/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c
  group CMSIS
    ../../../../../Program Files/IAR Systems/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group COMM
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group STM32
    ../../../../../Program Files/IAR Systems/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c

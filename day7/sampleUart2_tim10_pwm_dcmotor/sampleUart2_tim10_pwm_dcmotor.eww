<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_tim10_pwm_dcmotor.ewp</path>
    </project>
    <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_exti_PA8_PA11.ewp</path>
    </project>
    <batchBuild />
</workspace>

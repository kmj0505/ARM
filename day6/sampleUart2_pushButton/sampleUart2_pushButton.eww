<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_pushButton.ewp</path>
    </project>
    <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_project_split_ksh_v5_wifi.ewp</path>
    </project>
    <batchBuild />
</workspace>

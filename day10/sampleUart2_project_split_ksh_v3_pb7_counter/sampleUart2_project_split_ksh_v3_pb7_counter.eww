<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampleUart2_project_split_ksh_v3_pb7_counter.ewp</path>
    </project>
    <batchBuild />
</workspace>
